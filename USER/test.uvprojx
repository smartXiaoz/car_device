# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./GY.bin C:\Users\GY\Desktop\SKY32MCU-NV1.20_20191101\OBJ\test.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c misc: --c99
  c include: ..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE;..\HARDWARE\inc;..\HARDWARE\RADIO;..\TW2836;..\APP;..\APP\inc;..\APP\timers;.\CORE;..\uds
  memory RVCT4: ROM 0x800a000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUP
    ./: startup_stm32f10x_hd.s
  group APP
    ../APP/: app.h app.c
    ../APP/timers/: SOFtimers.c
    ../APP/src/: ledTASK.c InPutScanTASK.c wakeupTASK.c UartExpTASK.c uartTASK.c CanTASK.c udsTASK.c
  group USER
    ./: test.c
    ./CORE/: UartExp.c LAroundExp.c TestCMD.c
    ../TW2836/: tw2836.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ./CORE/: information.h information.c
    ../HARDWARE/: Hardware.h Hardware.c
    ../HARDWARE/src/: InPut.c OutPut.c adc.c timer.c stmflash.c EXTI.c can.c rtc.c I2C.c 24cxx.c dma.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/RADIO/: radio.c
  group FreeRTOS_CORE
    ../FreeRTOS/include/: FreeRTOSConfig.h
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group uds/CanIf
    ../uds/CanIf/: uds_can_driver.c uds_can_driver.h
  group uds/CanTp
    ../uds/CanTp/: canTp.c canTp.h
  group uds/Pdu
    ../uds/Pdu/: pdu.c pdu.h
  group uds/Dtc
    ../uds/Dtc/: dtc.c dtc.h
  group uds/Det
    ../uds/Det/: det.c det.h
  group uds/common
    ../uds/common/: Platform_Types.h uds_types.h
  group uds/Interface
    ../uds/Interface/: uds_cfg.c uds_cfg.h uds_interface.c uds_interface.h
  group README
    ../: README.TXT
